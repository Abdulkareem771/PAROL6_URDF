## microros_esp32/sdkconfig.defaults
```kconfig
CONFIG_ESP_MAIN_TASK_STACK_SIZE=4096
CONFIG_MICRO_ROS_TRANSPORT_UART=y
CONFIG_MICRO_ROS_CUSTOM_TRANSPORT=y
CONFIG_ESP_CONSOLE_UART_NONE=y
```
